# Keil uVision project CameraCapture.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CameraCapture +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40XX,HSE_VALUE=8000000,USE_STDPERIPH_DRIVER,HARD_FAULT_PRINT=1
  c include: ..\..\bsp\stm32f4xx\FWlib4xx\inc;..\..\bsp\stm32f4xx\CMSIS\inc;..\..\usrApp;..\..\drivers\inc;..\..\Middleware\Fatfs\src;..\..\Middleware\Fatfs\src\option;..\..\malloc;..\..\Middleware\Fatfs\exfuns;..\..\Middleware\PICTURE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp
    ../../bsp/stm32f4xx/FWlib4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../bsp/stm32f4xx/CMSIS/src/: system_stm32f4xx.c
  group drivers
    ../../drivers/src/: driver_misc.c rtc.c stm32f4xx_it.c hard_timer.c sys_misc.c bsp_uart.c bsp_ov2640.c bsp_sccb.c bsp_dcmi.c bsp_pwm.c bsp_led.c bsp_sdio_sd.c iwdg.c bsp_exti.c
  group doc
    ../../doc/: readme.txt
  group usrApp
    ../../usrApp/: main.c app_cfg.h debug.c debug.h WinMain.c WinMain.h
  group Middleware/Fatfs
    ../../Middleware/Fatfs/src/: diskio.c ff.c
    ../../Middleware/Fatfs/src/option/: cc936.c
    ../../Middleware/Fatfs/exfuns/: exfuns.c fattester.c
  group Startup
    ../../bsp/stm32f4xx/CMSIS/src/: startup_stm32f4xx.s
  group heap
    ../../malloc/: malloc.c
  group app
    ../../drivers/src/: photo.c jx_uart_send.c protocol.c
